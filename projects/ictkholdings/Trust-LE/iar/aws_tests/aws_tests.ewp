# IAR project aws_tests.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MT7697 Mediatek MT7697
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: MTK_DEBUG_LEVEL_INFO
  ICCARM.CCDiagSuppress: Pa050,Ta022,Ta023,Pe021
  ICCARM.IExtraOptions: -DMBEDTLS_THREADING_C; -DMBEDTLS_THREADING_ALT
  ICCARM.PreInclude: ..\..\..\..\..\vendors\ictkholdings\boards\Trust-LE-dev-kit\aws_tests\application_code\global.h
  ICCARM.CCIncludePath2: ..\..\..\..\..\freertos_kernel\include; ..\..\..\..\..\freertos_kernel\portable\IAR\ARM_CM4F; ..\..\..\..\..\tests\include; ..\..\..\..\..\demos\dev_mode_key_provisioning\include; ..\..\..\..\..\libraries\abstractions\wifi\test; ..\..\..\..\..\libraries\abstractions\ble_hal\include; ..\..\..\..\..\libraries\abstractions\ble_hal\test\include; ..\..\..\..\..\libraries\abstractions\platform\freertos\include\platform; ..\..\..\..\..\libraries\abstractions\platform\include; ..\..\..\..\..\libraries\abstractions\pkcs11\mbedtls; ..\..\..\..\..\libraries\abstractions\platform\freertos\include; ..\..\..\..\..\libraries\abstractions\platform\include; ..\..\..\..\..\libraries\abstractions\secure_sockets\include; ..\..\..\..\..\libraries\abstractions\wifi\include; ..\..\..\..\..\libraries\abstractions\secure_sockets\include; ..\..\..\..\..\libraries\abstractions\pkcs11\corePKCS11\source\include; ..\..\..\..\..\libraries\abstractions\pkcs11\corePKCS11\test\unit-test\config; ..\..\..\..\..\libraries\coreMQTT\source\include; ..\..\..\..\..\libraries\coreMQTT\source\interface; ..\..\..\..\..\libraries\c_sdk\standard\common\include\private; ..\..\..\..\..\libraries\c_sdk\standard\mqtt\src; ..\..\..\..\..\libraries\c_sdk\standard\mqtt\include; ..\..\..\..\..\libraries\c_sdk\standard\common\include; ..\..\..\..\..\libraries\c_sdk\aws\shadow\src; ..\..\..\..\..\libraries\c_sdk\aws\shadow\include; ..\..\..\..\..\libraries\c_sdk\standard\serializer\include; ..\..\..\..\..\libraries\c_sdk\standard\mqtt\test\access; ..\..\..\..\..\libraries\c_sdk\standard\mqtt\test\mock; ..\..\..\..\..\libraries\c_sdk\standard\serializer\include; ..\..\..\..\..\libraries\c_sdk\standard\ble\test; ..\..\..\..\..\libraries\c_sdk\standard\ble\include; ..\..\..\..\..\libraries\c_sdk\standard\serializer\include; ..\..\..\..\..\libraries\c_sdk\standard\ble\src; ..\..\..\..\..\libraries\freertos_plus\standard\utils\include; ..\..\..\..\..\libraries\freertos_plus\standard\crypto\include; ..\..\..\..\..\libraries\freertos_plus\standard\pkcs11\include; ..\..\..\..\..\libraries\freertos_plus\standard\tls\include; ..\..\..\..\..\libraries\freertos_plus\standard\tls\test; ..\..\..\..\..\libraries\freertos_plus\standard\crypto\include; ..\..\..\..\..\libraries\logging\include; ..\..\..\..\..\libraries\3rdparty\tracealyzer_recorder\Include; ..\..\..\..\..\libraries\3rdparty\jsmn; ..\..\..\..\..\libraries\3rdparty\mbedtls_utils; ..\..\..\..\..\libraries\3rdparty\tinycbor\src; ..\..\..\..\..\libraries\3rdparty\unity\extras\fixture\src; ..\..\..\..\..\libraries\3rdparty\unity\src; ..\..\..\..\..\libraries\3rdparty\pkcs11; ..\..\..\..\..\vendors\ictkholdings\boards\Trust-LE-dev-kit\aws_tests\application_code\mediatek_code\include; ..\..\..\..\..\vendors\ictkholdings\boards\Trust-LE-dev-kit\aws_tests\application_code\ictkholdings_code\include; ..\..\..\..\..\vendors\ictkholdings\boards\Trust-LE-dev-kit\aws_tests\config_files; ..\..\..\..\..\vendors\ictkholdings\sdk\kernel\service\inc; ..\..\..\..\..\vendors\ictkholdings\sdk\kernel\rtos\FreeRTOS\Source\portable\IAR\mt7687; ..\..\..\..\..\vendors\ictkholdings\sdk\kernel\portable\IAR\mt7687; ..\..\..\..\..\vendors\ictkholdings\sdk\driver\chip\mt7687\inc; ..\..\..\..\..\vendors\ictkholdings\sdk\driver\chip\inc; ..\..\..\..\..\vendors\ictkholdings\sdk\driver\CMSIS\Device\MTK\mt7687\Include; ..\..\..\..\..\vendors\ictkholdings\sdk\driver\board\mt76x7_hdk\util\inc; ..\..\..\..\..\vendors\ictkholdings\sdk\driver\board\mt76x7_hdk\ept\inc; ..\..\..\..\..\vendors\ictkholdings\sdk\middleware\MTK\minisupp\inc; ..\..\..\..\..\vendors\ictkholdings\sdk\middleware\MTK\nvdm\inc; ..\..\..\..\..\vendors\ictkholdings\sdk\middleware\third_party\lwip\ports\include; ..\..\..\..\..\vendors\ictkholdings\sdk\middleware\third_party\lwip\src\include; ..\..\..\..\..\vendors\ictkholdings\sdk\middleware\third_party\ping\inc; ..\..\..\..\..\vendors\ictkholdings\sdk\middleware\MTK\dhcpd\inc; ..\..\..\..\..\vendors\ictkholdings\sdk\middleware\MTK\wifi_service\combo\inc; ..\..\..\..\..\vendors\ictkholdings\sdk\driver\chip\mt7687\src\common\sdio_gen3\include; ..\..\..\..\..\vendors\ictkholdings\sdk\driver\chip\mt7687\src\common\include; ..\..\..\..\..\vendors\ictkholdings\sdk\driver\board\mt76x7_hdk\external_flash\inc; ..\..\..\..\..\vendors\ictkholdings\sdk\driver\board\mt76x7_hdk\util\inc; ..\..\..\..\..\vendors\ictkholdings\sdk\driver\board\mt76x7_hdk\ept\inc; ..\..\..\..\..\vendors\ictkholdings\sdk\kernel\extend\src; ..\..\..\..\..\vendors\ictkholdings\sdk\middleware\MTK\dhcpd\inc; ..\..\..\..\..\vendors\ictkholdings\sdk\kernel\service\inc; ..\..\..\..\..\vendors\ictkholdings\sdk\middleware\MTK\connsys\inc; ..\..\..\..\..\vendors\ictkholdings\sdk\kernel\service\syslog\inc; ..\..\..\..\..\vendors\ictkholdings\sdk\middleware\MTK\smtcn\inc; ..\..\..\..\..\vendors\ictkholdings\sdk\middleware\MTK\smtcn\inc\internal; ..\..\..\..\..\vendors\ictkholdings\sdk\kernel\service\inc; ..\..\..\..\..\vendors\ictkholdings\sdk\prebuilt\middleware\MTK\minisupp\inc; ..\..\..\..\..\vendors\ictkholdings\sdk\middleware\third_party\ping\inc; ..\..\..\..\..\vendors\ictkholdings\boards\Trust-LE-dev-kit\aws_tests\application_code\ictkholdings_code\include; ..\..\..\..\..\vendors\ictkholdings\sdk\middleware\MTK\atci\inc; ..\..\..\..\..\vendors\ictkholdings\sdk\middleware\MTK\verno\inc; ..\..\..\..\..\vendors\ictkholdings\sdk\middleware\ICTKHOLDINGS\g3\inc; ..\..\..\..\..\vendors\ictkholdings\sdk\middleware\ICTKHOLDINGS\mbedtls_g3\include; ..\..\..\..\..\vendors\ictkholdings\sdk\middleware\ICTKHOLDINGS\mbedtls_g3\configs; ..\..\..\..\..\vendors\ictkholdings\sdk\middleware\ICTKHOLDINGS\mbedtls_g3\include\mbedtls; ..\..\..\..\..\vendors\ictkholdings\sdk\middleware\third_party\lwip\src\include\lwip; ..\..\..\..\..\vendors\ictkholdings\boards\Trust-LE-dev-kit\ports\pkcs11\inc; ..\..\..\..\..\vendors\ictkholdings\sdk\middleware\MTK\bluetooth\inc; ..\..\..\..\..\vendors\ictkholdings\sdk\prebuilt\middleware\MTK\bluetooth\inc; ..\..\..\..\..\vendors\ictkholdings\boards\Trust-LE-dev-kit\ports\ble\inc; ..\..\..\..\..\vendors\ictkholdings\sdk\middleware\MTK\bt_notify\inc; ..\..\..\..\..\vendors\ictkholdings\sdk\middleware\MTK\ble_serial\inc; ..\..\..\..\..\vendors\ictkholdings\sdk\middleware\MTK\bt_notify\inc\dogp; ..\..\..\..\..\vendors\ictkholdings\sdk\middleware\MTK\bt_callback_manager\inc; ..\..\..\..\..\vendors\ictkholdings\sdk\middleware\MTK\bluetooth_service\inc; ..\..\..\..\..\libraries\abstractions\backoff_algorithm\source\include; ..\..\..\..\..\libraries\abstractions\transport\secure_sockets
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.AUserIncludes: ..\..\..\..\..\vendors\ictkholdings\boards\Trust-LE-dev-kit\aws_tests\config_files\; ..\..\..\..\..\libraries\3rdparty\unity\src
  OBJCOPY.OOCOutputFile: aws_tests.bin
  ILINK.IlinkOutputFile: aws_tests.out
  ILINK.IlinkKeepSymbols: __bootloader
  ILINK.IlinkIcfFile: ..\..\..\..\..\vendors\ictkholdings\boards\Trust-LE-dev-kit\aws_tests\flash.icf
  ILINK.IlinkExtraOptions: --redirect malloc=pvPortMalloc; --redirect calloc=pvPortCalloc; --redirect realloc=pvPortRealloc; --redirect free=vPortFree
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 0
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  ICCARM.IccLang: 0
  group apps
    ../../../../../vendors/ictkholdings/boards/Trust-LE-dev-kit/aws_tests/application_code/: main.c
    ../../../../../vendors/ictkholdings/boards/Trust-LE-dev-kit/aws_tests/application_code/ictkholdings_code/source/: test_print.c
  group apps/mediatek_code
    ../../../../../vendors/ictkholdings/boards/Trust-LE-dev-kit/aws_tests/application_code/mediatek_code/source/: mediatek_app.a
  group common
    ../../../../../libraries/c_sdk/standard/common/: iot_device_metrics.c iot_init.c iot_static_memory_common.c
  group connsys
    ../../../../../vendors/ictkholdings/sdk/middleware/MTK/connsys/src/: connsys.a
  group connsys/N9
    ../../../../../vendors/ictkholdings/sdk/middleware/MTK/connsys/src/: mt76X7_n9_image.c
  group demos
    ../../../../../demos/dev_mode_key_provisioning/src/: aws_dev_mode_key_provisioning.c
  group hal_drivers
    ../../../../../vendors/ictkholdings/sdk/driver/chip/mt7687/src/: hal_driver.a
  group iarfs
    $EW_DIR$/arm/src/lib/file/: close.c lseek.c open.c read.c remove.c write.c
  group jsmn
    ../../../../../libraries/3rdparty/jsmn/: jsmn.c
  group kernel
    ../../../../../freertos_kernel/: event_groups.c list.c queue.c tasks.c timers.c
    ../../../../../freertos_kernel/portable/MemMang/: heap_4.c
    ../../../../../vendors/ictkholdings/sdk/kernel/service/src/: kernel_service.a
    ../../../../../freertos_kernel/portable/IAR/ARM_CM4F/: port.c portasm.s
    ../../../../../vendors/ictkholdings/sdk/kernel/portable/IAR/mt7687/: port_tick.c
    ../../../../../vendors/ictkholdings/sdk/kernel/service/syslog/src/: syslog.a
    ../../../../../vendors/ictkholdings/sdk/kernel/extend/src/: wrap_heap.c
  group libraries/abstractions
    ../../../../../libraries/abstractions/backoff_algorithm/source/: backoff_algorithm.c
    ../../../../../libraries/abstractions/transport/secure_sockets/: transport_secure_sockets.c
  group libraries/ble
    ../../../../../libraries/c_sdk/standard/ble/src/: iot_ble_gap.c iot_ble_gatt.c
  group libraries/ble/device_information
    ../../../../../libraries/c_sdk/standard/ble/src/services/mqtt_ble/: iot_network_ble.c
  group libraries/ble/mqtt
    ../../../../../libraries/c_sdk/standard/ble/src/services/device_information/: iot_ble_device_information.c
    ../../../../../libraries/c_sdk/standard/ble/src/services/mqtt_ble/: iot_ble_mqtt_serialize.c
  group libraries/ble/service
    ../../../../../libraries/c_sdk/standard/ble/src/services/data_transfer/: iot_ble_data_transfer.c
  group libraries/ble/wifi_provisioning
    ../../../../../libraries/c_sdk/standard/ble/src/services/wifi_provisioning/: iot_ble_wifi_provisioning.c
  group libraries/cbor
    ../../../../../libraries/3rdparty/tinycbor/src/: cborencoder.c cborencoder_close_container_checked.c cborerrorstrings.c cborparser.c cborparser_dup_string.c cborpretty.c cborpretty_stdio.c cborvalidation.c
    ../../../../../libraries/c_sdk/standard/serializer/src/cbor/: iot_serializer_tinycbor_decoder.c iot_serializer_tinycbor_encoder.c
  group libraries/json
    ../../../../../libraries/c_sdk/standard/serializer/src/: iot_json_utils.c
  group libraries/logging
    ../../../../../libraries/logging/: iot_logging.c iot_logging_task_dynamic_buffers.c
  group libraries/mqtt
    ../../../../../libraries/c_sdk/standard/mqtt/src/: iot_mqtt_agent.c iot_mqtt_api.c iot_mqtt_context_connection.c iot_mqtt_managed_function_wrapper.c iot_mqtt_mutex_wrapper.c iot_mqtt_network.c iot_mqtt_operation.c iot_mqtt_publish_duplicates.c iot_mqtt_serializer_deserializer_wrapper.c iot_mqtt_static_memory.c iot_mqtt_subscription.c iot_mqtt_subscription_container.c iot_mqtt_validate.c
  group libraries/mqtt/coreMQTT
    ../../../../../libraries/coreMQTT/source/: core_mqtt.c core_mqtt_serializer.c core_mqtt_state.c
  group libraries/pkcs11
    ../../../../../libraries/abstractions/pkcs11/corePKCS11/source/: core_pki_utils.c
  group libraries/platform
    ../../../../../libraries/abstractions/platform/freertos/: iot_clock_freertos.c iot_metrics.c iot_network_freertos.c iot_threads_freertos.c
  group libraries/shadow
    ../../../../../libraries/c_sdk/aws/shadow/src/: aws_iot_shadow_api.c aws_iot_shadow_operation.c aws_iot_shadow_parser.c aws_iot_shadow_static_memory.c aws_iot_shadow_subscription.c aws_shadow.c aws_shadow_config_defaults.h
  group libraries/system
    ../../../../../libraries/freertos_plus/standard/utils/src/: iot_system_init.c
  group mbedtls/common
    ../../../../../vendors/ictkholdings/sdk/middleware/ICTKHOLDINGS/mbedtls_g3/library/common/: util.c
  group mbedtls/ictk
    ../../../../../vendors/ictkholdings/sdk/middleware/ICTKHOLDINGS/mbedtls_g3/source/ictk/: aes_interface.c ecdsa_interface.c pkparse_interface.c profile.c ssl_cli_interface.c ssl_tls_interface.c x509write_crt_interface.c x509write_csr_interface.c
  group mbedtls/src
    ../../../../../vendors/ictkholdings/sdk/middleware/ICTKHOLDINGS/mbedtls_g3/library/: aes.c aes_alt.c aesni.c arc4.c aria.c asn1parse.c asn1write.c base64.c bignum.c blowfish.c camellia.c ccm.c certs.c chacha20.c chachapoly.c cipher.c cipher_wrap.c cmac.c ctr_drbg.c debug.c des.c des_alt.c dhm.c ecdh.c ecdsa.c ecjpake.c ecp.c ecp_curves.c entropy.c entropy_hardware_poll.c entropy_poll.c error.c gcm.c havege.c hkdf.c hmac_drbg.c md.c md2.c md4.c md5.c md5_alt.c md_wrap.c memory_buffer_alloc.c net_sockets.c nist_kw.c oid.c padlock.c pem.c pk.c pk_wrap.c pkcs11.c pkcs12.c pkcs5.c pkparse.c pkwrite.c platform.c platform_util.c poly1305.c ripemd160.c rsa.c rsa_internal.c sha1.c sha1_alt.c sha256.c sha256_alt.c sha512.c sha512_alt.c ssl_cache.c ssl_ciphersuites.c ssl_cli.c ssl_cookie.c ssl_srv.c ssl_ticket.c ssl_tls.c threading.c threading_alt.c timing.c version.c version_features.c x509.c x509_create.c x509_crl.c x509_crt.c x509_csr.c x509write_crt.c x509write_csr.c xtea.c
  group mbedtls/utils
    ../../../../../libraries/3rdparty/mbedtls_utils/: mbedtls_error.c mbedtls_utils.c
  group middleware/3rdparty/lwip/api
    ../../../../../vendors/ictkholdings/sdk/middleware/third_party/lwip/src/api/: api_lib.c api_msg.c err.c if_api.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group middleware/3rdparty/lwip/core
    ../../../../../vendors/ictkholdings/sdk/middleware/third_party/lwip/src/core/: altcp.c altcp_alloc.c altcp_tcp.c def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
  group middleware/3rdparty/lwip/core/ipv4
    ../../../../../vendors/ictkholdings/sdk/middleware/third_party/lwip/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
  group middleware/3rdparty/lwip/core/ipv6
    ../../../../../vendors/ictkholdings/sdk/middleware/third_party/lwip/src/core/ipv6/: dhcp6.c ethip6.c icmp6.c inet6.c ip6.c ip6_addr.c ip6_frag.c mld6.c nd6.c
  group middleware/3rdparty/lwip/netif
    ../../../../../vendors/ictkholdings/sdk/middleware/third_party/lwip/src/netif/: bridgeif.c bridgeif_fdb.c ethernet.c lowpan6.c lowpan6_ble.c lowpan6_common.c slipif.c zepif.c
  group middleware/3rdparty/lwip/ports
    ../../../../../vendors/ictkholdings/sdk/middleware/third_party/lwip/ports/: ethernetif.c lwip_log.c sys_arch.c
  group middleware/3rdparty/ping
    ../../../../../vendors/ictkholdings/sdk/middleware/third_party/ping/src/: ping.c
  group middleware/ictk/g3
    ../../../../../vendors/ictkholdings/sdk/middleware/ICTKHOLDINGS/g3/src/: g3.a
  group middleware/ictk/pkcs11
    ../../../../../vendors/ictkholdings/sdk/middleware/ICTKHOLDINGS/g3/src/: g3_pkcs11.c
    ../../../../../vendors/ictkholdings/sdk/middleware/ICTKHOLDINGS/pkcs11_g3/: iot_pkcs11.c iot_pkcs11_mbedtls.c
  group middleware/MTK/atci
    ../../../../../vendors/ictkholdings/sdk/middleware/MTK/atci/src/: atci.a
  group middleware/MTK/dhcpd
    ../../../../../vendors/ictkholdings/sdk/middleware/MTK/dhcpd/src/: dhcpd.a
  group middleware/MTK/nvdm
    ../../../../../vendors/ictkholdings/sdk/prebuilt/middleware/MTK/nvdm/lib/: libnvdm_CM4_IAR.a
    ../../../../../vendors/ictkholdings/sdk/middleware/MTK/nvdm/src/: nvdm_port.a
  group mt7687
    ../../../../../vendors/ictkholdings/sdk/driver/chip/mt7687/src/common/: mt7687.a
  group ports/crypto
    ../../../../../vendors/ictkholdings/boards/Trust-LE-dev-kit/ports/crypto/: iot_crypto.c
  group ports/pkcs11
    ../../../../../vendors/ictkholdings/boards/Trust-LE-dev-kit/ports/pkcs11/src/: iot_pkcs11_pal.c
  group ports/secure_sockets
    ../../../../../vendors/ictkholdings/boards/Trust-LE-dev-kit/ports/secure_sockets/: iot_secure_sockets.c
  group ports/tls
    ../../../../../vendors/ictkholdings/boards/Trust-LE-dev-kit/ports/tls/: iot_tls.c
  group ports/wifi
    ../../../../../vendors/ictkholdings/boards/Trust-LE-dev-kit/ports/wifi/: iot_wifi.c
  group prebuilt
    ../../../../../vendors/ictkholdings/sdk/prebuilt/driver/chip/mt7687/lib/: libhal_core_CM4_IAR.a libhal_protected_CM4_IAR.a
  group smtcn
    ../../../../../vendors/ictkholdings/sdk/prebuilt/middleware/MTK/smtcn/lib/: libbcsmtcn_CM4_IAR.a libmcsmtcn_CM4_IAR.a
    ../../../../../vendors/ictkholdings/sdk/middleware/MTK/smtcn/src/: smtcn.a
  group tests
    ../../../../../tests/common/: aws_test.c aws_test_framework.c aws_test_runner.c iot_test_freertos.c iot_tests_network.c
    ../../../../../libraries/c_sdk/standard/common/taskpool/: iot_taskpool.c
  group tests/ble
    ../../../../../libraries/c_sdk/standard/ble/test/: iot_test_ble_end_to_end.c iot_test_ble_mqtt_serialize.c iot_test_wifi_provisioning.c
    ../../../../../libraries/abstractions/ble_hal/test/src/: iot_test_ble_hal_afqp.c iot_test_ble_hal_common.c iot_test_ble_hal_integration.c iot_test_ble_hal_kpi.c iot_test_ble_hal_stress_test.c
  group tests/crypto
    ../../../../../libraries/freertos_plus/standard/crypto/test/: iot_test_crypto.c
  group tests/mqtt
    ../../../../../tests/integration_test/: core_mqtt_system_test.c
    ../../../../../libraries/c_sdk/standard/mqtt/test/: iot_test_mqtt_agent.c
    ../../../../../libraries/c_sdk/standard/mqtt/test/unit/: iot_tests_mqtt_api.c iot_tests_mqtt_metrics.c iot_tests_mqtt_receive.c iot_tests_mqtt_subscription.c iot_tests_mqtt_validate.c
    ../../../../../libraries/c_sdk/standard/mqtt/test/mock/: iot_tests_mqtt_mock.c
    ../../../../../libraries/c_sdk/standard/mqtt/test/system/: iot_tests_mqtt_system.c
  group tests/pkcs11
    ../../../../../libraries/abstractions/pkcs11/test/: iot_test_pkcs11.c
  group tests/shadow
    ../../../../../libraries/c_sdk/aws/shadow/test/unit/: aws_iot_tests_shadow_api.c aws_iot_tests_shadow_parser.c
    ../../../../../libraries/c_sdk/aws/shadow/test/system/: aws_iot_tests_shadow_system.c
    ../../../../../libraries/c_sdk/aws/shadow/test/: aws_test_shadow.c
  group tests/tcp
    ../../../../../libraries/abstractions/secure_sockets/test/: iot_test_tcp.c
  group tests/tls
    ../../../../../libraries/freertos_plus/standard/tls/test/: iot_test_tls.c
  group tests/wifi
    ../../../../../libraries/abstractions/wifi/test/: iot_test_wifi.c
  group unity
    ../../../../../libraries/3rdparty/unity/src/: unity.c
    ../../../../../libraries/3rdparty/unity/extras/fixture/src/: unity_fixture.c
  group wifi
    ../../../../../vendors/ictkholdings/sdk/prebuilt/middleware/MTK/wifi_service/combo/lib/wifi_supp/: libwifi_CM4_IAR.a
  group wifi/combo
    ../../../../../vendors/ictkholdings/sdk/middleware/MTK/wifi_service/combo/src/: wifi_combo.a
  group wifi/combo/init
    ../../../../../vendors/ictkholdings/sdk/middleware/MTK/wifi_service/combo/src/init/: wifi_init.a
  group wifi/combo/wifi_os_ext
    ../../../../../vendors/ictkholdings/sdk/middleware/MTK/wifi_service/combo/src/wifi_os_ext/: wifi_os_ext.a
  group wifi/minisupp
    ../../../../../vendors/ictkholdings/sdk/prebuilt/middleware/MTK/minisupp/lib/: libminisupp_wps_CM4_IAR.a
